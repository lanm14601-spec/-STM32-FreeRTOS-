# Keil uVision project RTOSDemo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOSDemo
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102
  c include: ..\CORTEX_STM32F103_Keil;.\serial;..\..\Source\include;.\STM32F10xFWLib\inc;.\ADC;.\Light;.\DHT11;.\OLED;.\Key;.\Console
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./: STM32F10x.s
    ../Common/drivers/ST/STM32F10xFWLib/src/: cortexm3_macro_rvds.s
    ./STM32F10xFWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c
    ./vendor/: stm32f10x_adc.c
  group Demo Files
    ./serial/: serial.c
    ./: main.c
  group FreeRTOS files
    ../../Source/: tasks.c list.c queue.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
    ../../Source/portable/MemMang/: heap_2.c
  group BSP
    ./ADC/: bsp_adc.c
  group APP
    ./ADC/: adc_filter.c app_adc.c
  group Light
    ./Light/: light_process.c
  group DHT11
    ./DHT11/: app_dht11.c bsp_dht11.c dht11_protocol.c
  group OLED
    ./OLED/: app_display.c bsp_oled_bus.c display_view.c oled_text.c ssd1306.c ui_navigation.c
  group Key
    ./Key/: app_key.c bsp_key.c key_logic.c
  group console
    ./Console/: app_console.c console_protocol.c
